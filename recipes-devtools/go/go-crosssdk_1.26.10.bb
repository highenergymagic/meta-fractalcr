# OE-Core Wrynose recipe, updated for the Go security release.
require recipes-devtools/go/go-crosssdk.inc
require go-${PV}.inc
