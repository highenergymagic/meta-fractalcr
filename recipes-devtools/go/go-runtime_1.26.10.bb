# OE-Core Wrynose recipe, updated for the Go security release.
require go-${PV}.inc
require recipes-devtools/go/go-runtime.inc

