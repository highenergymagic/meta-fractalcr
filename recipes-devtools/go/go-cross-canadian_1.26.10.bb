# OE-Core Wrynose recipe, updated for the Go security release.
require recipes-devtools/go/go-cross-canadian.inc
require go-${PV}.inc
